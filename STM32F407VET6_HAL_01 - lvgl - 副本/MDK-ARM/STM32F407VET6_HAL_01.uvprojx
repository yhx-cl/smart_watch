# Keil uVision project STM32F407VET6_HAL_01.uvprojx, settings and files
target STM32F407VET6_HAL_01 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407VET6_HAL_01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\MDwares;..\MDwares\LVGL;..\MDwares\LVGL\GUI\lvgl\src;..\MDwares\LVGL\GUI\lvgl\examples\porting;..\MDwares\LVGL\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: lcd.c image1.c image2lcd.c ctiic.c GT911.c touch.c text.c main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MDwares/lvgl
    ../MDwares/: calendar_icon.c calendar_ui.c Game_2048.c game2048.c home.c
  group MDwares/lvgl/example/porting
    ../MDwares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group MDwares/lvgl/src/draw
    ../MDwares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../MDwares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group MDwares/lvgl/src/extra
    ../MDwares/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../MDwares/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group MDwares/lvgl/src/font
    ../MDwares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group MDwares/lvgl/src/gpu
    ../MDwares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_polygon.c lv_draw_sdl_mask.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../MDwares/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group MDwares/lvgl/src/hal
    ../MDwares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group MDwares/lvgl/src/misc
    ../MDwares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group MDwares/lvgl/src/widgets
    ../MDwares/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group MDwares/lvgl/src/core
    ../MDwares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
software components: CMSIS:CORE 4.3.0
